# IAR project ATSAME54XPRO.ewp, settings and files
configuration ATSAME54XPRO (ARM, debug)
  General.OGChipSelectEditMenu: ATSAME54P20A Microchip ATSAME54P20A
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_HAL_DRIVER; __SAME54P20A__; SYSINFO_OS_VERSION="APP-1.0.0"; SYSINFO_PRODUCT_MODEL="ALI_AOS_ATSAME54XPRO"; SYSINFO_DEVICE_NAME="ATSAME54XPRO"; SYSINFO_KERNEL_VERSION="AOS-R-1.2.2"; SYSINFO_APP_VERSION="APP-1.0.0"; STDIO_UART=0; CONFIG_NO_TCPIP; __BSD_VISIBLE; RHINO_CONFIG_TICK_TASK=0; _TIMESPEC_DEFINED
  ICCARM.CCIncludePath2: ..\..\..\..\include; ..\..\..\..\kernel\rhino\core\include; ..\..\..\..\platform\arch\arm\armv7m\iccarm\m4; ..\..\..\..\include\hal; ..\..\..\..\kernel\vcall\aos; ..\..\..\..\utility\libc\compilers\iar; ..\..\..\..\platform\mcu\atsamd5x_e5x\Drivers; ..\..\..\..\platform\mcu\atsamd5x_e5x\Drivers\config; ..\..\..\..\platform\mcu\atsamd5x_e5x\Drivers\hal\include; ..\..\..\..\platform\mcu\atsamd5x_e5x\Drivers\hal\utils\include; ..\..\..\..\platform\mcu\atsamd5x_e5x\Drivers\hri; ..\..\..\..\platform\mcu\atsamd5x_e5x\Drivers\CMSIS\Include; ..\..\..\..\platform\mcu\atsamd5x_e5x\Drivers\include; ..\..\..\..\platform\mcu\atsamd5x_e5x\src\ATSAME54-XPRO\helloworld
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: ATSAME54XPRO.srec
  ILINK.IlinkOutputFile: ATSAME54XPRO.out
  ILINK.IlinkIcfFile: same54p20a_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group AOS/Arch
    ../../../../platform/arch/arm/armv7m/iccarm/m4/: port_c.c port_s.S
  group AOS/Kernel
    ../../../../kernel/rhino/core/: k_buf_queue.c k_dyn_mem_proc.c k_err.c k_event.c k_idle.c k_mm.c k_mm_blk.c k_mm_debug.c k_mutex.c k_obj.c k_pend.c k_queue.c k_ringbuf.c k_sched.c k_sem.c k_stats.c k_sys.c k_task.c k_task_sem.c k_tick.c k_time.c k_timer.c k_workqueue.c
  group AOS/Libc
    ../../../../utility/libc/compilers/iar/: iar_libc.c
  group Application
    ../../../../platform/mcu/atsamd5x_e5x/aos/: soc_impl.c soc_init.c
  group Drivers
    ../../../../platform/mcu/atsamd5x_e5x/Drivers/: atmel_start.c atmel_start.h atmel_start_pins.h driver_init.c driver_init.h
  group Drivers/CMSIS/Include
    ../../../../platform/mcu/atsamd5x_e5x/Drivers/CMSIS/Include/: arm_common_tables.h arm_const_structs.h arm_math.h cmsis_armcc.h cmsis_armclang.h cmsis_compiler.h cmsis_gcc.h core_armv8mbl.h core_armv8mml.h core_cm0.h core_cm0plus.h core_cm23.h core_cm3.h core_cm33.h core_cm4.h core_cm7.h core_sc000.h core_sc300.h tz_context.h
  group Drivers/config
    ../../../../platform/mcu/atsamd5x_e5x/Drivers/config/: hpl_dmac_config.h hpl_gclk_config.h hpl_mclk_config.h hpl_osc32kctrl_config.h hpl_oscctrl_config.h hpl_sercom_config.h hpl_systick_config.h peripheral_clk_config.h
  group Drivers/hal/include
    ../../../../platform/mcu/atsamd5x_e5x/Drivers/hal/include/: hal_atomic.h hal_delay.h hal_flash.h hal_gpio.h hal_init.h hal_io.h hal_sleep.h hal_usart_sync.h hpl_core.h hpl_delay.h hpl_dma.h hpl_flash.h hpl_gpio.h hpl_i2c_m_async.h hpl_i2c_m_sync.h hpl_i2c_s_async.h hpl_i2c_s_sync.h hpl_init.h hpl_irq.h hpl_missing_features.h hpl_ramecc.h hpl_reset.h hpl_sleep.h hpl_spi.h hpl_spi_async.h hpl_spi_m_async.h hpl_spi_m_dma.h hpl_spi_m_sync.h hpl_spi_s_async.h hpl_spi_s_sync.h hpl_spi_sync.h hpl_usart.h hpl_usart_async.h hpl_usart_sync.h
  group Drivers/hal/src
    ../../../../platform/mcu/atsamd5x_e5x/Drivers/hal/src/: hal_atomic.c hal_delay.c hal_flash.c hal_gpio.c hal_init.c hal_io.c hal_sleep.c hal_usart_sync.c
  group Drivers/hal/utils/include
    ../../../../platform/mcu/atsamd5x_e5x/Drivers/hal/utils/include/: compiler.h err_codes.h events.h parts.h utils.h utils_assert.h utils_event.h utils_increment_macro.h utils_list.h utils_repeat_macro.h utils_ringbuffer.h
  group Drivers/hal/utils/src
    ../../../../platform/mcu/atsamd5x_e5x/Drivers/hal/utils/src/: utils_assert.c utils_event.c utils_list.c utils_ringbuffer.c utils_syscalls.c
  group Drivers/hpl/core
    ../../../../platform/mcu/atsamd5x_e5x/Drivers/hpl/core/: hpl_core_m4.c hpl_core_port.h hpl_init.c
  group Drivers/hpl/dmac
    ../../../../platform/mcu/atsamd5x_e5x/Drivers/hpl/dmac/: hpl_dmac.c
  group Drivers/hpl/gclk
    ../../../../platform/mcu/atsamd5x_e5x/Drivers/hpl/gclk/: hpl_gclk.c hpl_gclk_base.h
  group Drivers/hpl/mclk
    ../../../../platform/mcu/atsamd5x_e5x/Drivers/hpl/mclk/: hpl_mclk.c
  group Drivers/hpl/nvmctrl
    ../../../../platform/mcu/atsamd5x_e5x/Drivers/hpl/nvmctrl/: hpl_nvmctrl.c
  group Drivers/hpl/osc32kctrl
    ../../../../platform/mcu/atsamd5x_e5x/Drivers/hpl/osc32kctrl/: hpl_osc32kctrl.c
  group Drivers/hpl/oscctrl
    ../../../../platform/mcu/atsamd5x_e5x/Drivers/hpl/oscctrl/: hpl_oscctrl.c
  group Drivers/hpl/pm
    ../../../../platform/mcu/atsamd5x_e5x/Drivers/hpl/pm/: hpl_pm.c hpl_pm_base.h
  group Drivers/hpl/port
    ../../../../platform/mcu/atsamd5x_e5x/Drivers/hpl/port/: hpl_gpio_base.h
  group Drivers/hpl/ramecc
    ../../../../platform/mcu/atsamd5x_e5x/Drivers/hpl/ramecc/: hpl_ramecc.c
  group Drivers/hpl/sercom
    ../../../../platform/mcu/atsamd5x_e5x/Drivers/hpl/sercom/: hpl_sercom.c
  group Drivers/hpl/systick
    ../../../../platform/mcu/atsamd5x_e5x/Drivers/hpl/systick/: hpl_systick.c
  group Drivers/hri
    ../../../../platform/mcu/atsamd5x_e5x/Drivers/hri/: hri_ac_e54.h hri_adc_e54.h hri_aes_e54.h hri_can_e54.h hri_ccl_e54.h hri_cmcc_e54.h hri_dac_e54.h hri_dmac_e54.h hri_dsu_e54.h hri_e54.h hri_eic_e54.h hri_evsys_e54.h hri_freqm_e54.h hri_gclk_e54.h hri_gmac_e54.h hri_hmatrixb_e54.h hri_i2s_e54.h hri_icm_e54.h hri_mclk_e54.h hri_mpu_e54.h hri_nvic_e54.h hri_nvmctrl_e54.h hri_osc32kctrl_e54.h hri_oscctrl_e54.h hri_pac_e54.h hri_pcc_e54.h hri_pdec_e54.h hri_pm_e54.h hri_port_e54.h hri_qspi_e54.h hri_ramecc_e54.h hri_rstc_e54.h hri_rtc_e54.h hri_sdhc_e54.h hri_sercom_e54.h hri_supc_e54.h hri_systemcontrol_e54.h hri_systick_e54.h hri_tc_e54.h hri_tcc_e54.h hri_trng_e54.h hri_usb_e54.h hri_wdt_e54.h
  group Drivers/iar
    ../../../../platform/mcu/atsamd5x_e5x/Drivers/iar/: system_same54.c
  group Drivers/iar/iar
    ../../../../platform/mcu/atsamd5x_e5x/Drivers/iar/iar/: startup_same54.c
  group Drivers/include
    ../../../../platform/mcu/atsamd5x_e5x/Drivers/include/: component-version.h sam.h same54.h same54n19a.h same54n20a.h same54p19a.h same54p20a.h system_same54.h
  group Drivers/include/components
    ../../../../platform/mcu/atsamd5x_e5x/Drivers/include/component/: ac.h adc.h aes.h can.h ccl.h cmcc.h dac.h dmac.h dsu.h eic.h evsys.h freqm.h gclk.h gmac.h hmatrixb.h i2s.h icm.h mclk.h nvmctrl.h osc32kctrl.h oscctrl.h pac.h pcc.h pdec.h picop.h pm.h port.h qspi.h ramecc.h rstc.h rtc.h sdhc.h sercom.h supc.h tal.h tc.h tcc.h trng.h usb.h wdt.h
  group Drivers/include/instance
    ../../../../platform/mcu/atsamd5x_e5x/Drivers/include/instance/: ac.h adc0.h adc1.h aes.h can0.h can1.h ccl.h cmcc.h dac.h dmac.h dsu.h eic.h evsys.h freqm.h gclk.h gmac.h hmatrix.h i2s.h icm.h mclk.h nvmctrl.h osc32kctrl.h oscctrl.h pac.h pcc.h pdec.h picop.h pm.h port.h pukcc.h qspi.h ramecc.h rstc.h rtc.h sdhc0.h sdhc1.h sercom0.h sercom1.h sercom2.h sercom3.h sercom4.h sercom5.h sercom6.h sercom7.h supc.h tal.h tc0.h tc1.h tc2.h tc3.h tc4.h tc5.h tc6.h tc7.h tcc0.h tcc1.h tcc2.h tcc3.h tcc4.h trng.h usb.h wdt.h
  group Drivers/include/pio
    ../../../../platform/mcu/atsamd5x_e5x/Drivers/include/pio/: same54n19a.h same54n20a.h same54p19a.h same54p20a.h
  group Drivers/src
    ../../../../platform/mcu/atsamd5x_e5x/hal/: hal_uart_start.c
  group Example
    ../../../../example/rhinorun/: rhinorun.c
  group src/ATSAME54-XPRO/helloworld
    ../../../../platform/mcu/atsamd5x_e5x/src/ATSAME54-XPRO/helloworld/: k_config.h
